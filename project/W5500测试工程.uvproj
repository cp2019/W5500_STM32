# Keil uVision project W5500测试工程.uvproj, settings and files
target W5500测试工程 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: 01_W5500测试工程 +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1
  c include: ..\Hardwave;..\system;..\user;..\Program\ucOS_II\Source;..\Program\ucOS_II\CortexM3;..\UserTask;..\Hardwave\W5500;..\BoardSupport
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group start
    ../system/startup/: cortexm3_macro.s startup_stm32f10x_hd.s
  group system
    ../system/: DELAY.c SYSTEM.C GPIO_INIT.c
  group user
    ../user/: main.c
  group Hardwave
    ../Hardwave/: LED.c USART.c wdg.c STM32Flash.c DMA.c SPI.c STM32Flash_Lock.c
    ../Hardwave/W5500/: W5500.c w5500_socket.c dhcp.c
  group ucOS_II
    ../Program/ucOS_II/CortexM3/: os_cpu_c.c app_cfg.h cpu.h cpu_a.asm cpu_def.h os_cpu.h os_cpu_a.asm
    ../Program/ucOS_II/Source/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_cfg.h
  group UserTask
    ../UserTask/: W5500_Task.c SOCKET_Tas.c
  group BoardSupport
    ../BoardSupport/: board.c
